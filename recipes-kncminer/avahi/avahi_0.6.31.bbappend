EXTRA_OECONF += " \
	     --disable-dbus \
	     "
